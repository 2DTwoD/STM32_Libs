# Keil uVision project STM32_Libs.uvprojx, settings and files
target App (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Libs
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c include: .\Application\Analog\inc;.\FreeRTOS\Inc;.\FreeRTOS\ARM_CM3;.\Tasks\Inc;.\Application\Control\inc;.\Application\Discrete\inc;.\Application\Main\inc;.\Application\Misc\inc;.\Application\Observe\inc;.\Application\Timer\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/Main/src/: main.cpp
    ./Application/Main/inc/: main.h
  group FreeRTOS
    ./FreeRTOS/Src/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/ARM_CM3/: port.c
  group Tasks
    ./Tasks/Src/: led_task.cpp test_task.cpp pidTask.cpp
    ./Tasks/Inc/: all_tasks.h
  group Misc
    ./Application/Misc/src/: common.cpp init.cpp
    ./Application/Misc/inc/: common.h init.h interfaces.h scale.h
  group Analog
    ./Application/Analog/src/: analog_monitor.cpp analog_out.cpp
    ./Application/Analog/inc/: analog_monitor.h analog_out.h
  group Discrete
    ./Application/Discrete/src/: coil.cpp gpio_common.cpp simple_input.cpp switch_delay.cpp
    ./Application/Discrete/inc/: coil.h gpio_common.h simple_input.h switch_delay.h
  group Timer
    ./Application/Timer/src/: common_timer.cpp
    ./Application/Timer/inc/: common_timer.h
  group Control
    ./Application/Control/src/: pid.cpp ramp.cpp three_pos.cpp two_pos.cpp
    ./Application/Control/inc/: mux.h pid.h ramp.h three_pos.h two_pos.h
  group Observe
    ./Application/Observe/src/: monitor.cpp moving_avg.cpp
    ./Application/Observe/inc/: monitor.h moving_avg.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
